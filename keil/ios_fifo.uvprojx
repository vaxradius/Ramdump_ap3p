# Keil uVision project ios_fifo.uvprojx, settings and files
target ios_fifo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ios_fifo
  AfterMake: fromelf --bin --output bin\ios_fifo.bin bin\ios_fifo.axf
  AfterMake: fromelf -cedrst --output bin\ios_fifo.txt bin\ios_fifo.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3P AM_PACKAGE_BGA keil
  c include: ../../../../../mcu/apollo3p;../../../../..;../../../../../CMSIS/AmbiqMicro/Include;../../../../../utils;../../../../../devices;../../../../../CMSIS/ARM/Include;../../../bsp;../src;..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include;..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\Keil\AMapollo2
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: ios_fifo.c rtos.c ramdump_task.c fault_data.c am_storage.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3p/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
  group freeRTOS
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
